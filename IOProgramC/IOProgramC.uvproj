# Keil uVision project IOProgramC.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC812 Analog Devices
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(11059200) DPX
  output: IOProgramC +hex
  c flags: Optimize=1 SizeSpeed=1
  group Source Group 1
    ../LAB2/: IOProgramC.c
